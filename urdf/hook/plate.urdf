Commit message: Update hook direction

File: urdf/hook/plate.urdf (robot description, URDF)
Before this commit: robot plate, 1 links, 0 joints
Links:
- link link: geometry collision box size=0.01 0.1 0.1; visual box size=0.01 0.1 0.1
