Commit message: Add textured base urdf

File: urdf/base/base.urdf (robot description, URDF)
Before this commit: robot base.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=base.obj scale=1 1 1; visual mesh filename=base.obj scale=1 1 1
